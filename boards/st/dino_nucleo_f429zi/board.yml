## boards/st/dino_nucleo_f429zi/board.yml
```yaml
board:
  name: dino_nucleo_f429zi
  full_name: Dino Nucleo F429ZI
  vendor: st
  socs:
    - name: stm32f429xx
```
